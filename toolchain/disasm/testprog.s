        abcd    -(a3),-(a4)
        abcd    -(a6),-(a7)
        abcd    d1,d2
        abcd    d3,d4
        add.b   #$12,d4
        add.b   $12(a6,a7),d5
        add.b   $12(a6,d7),d6
        add.b   $12(pc,a1),d2
        add.b   $12(pc,d2),d3
        add.b   $1234(a5),d4
        add.b   $1234(pc),d1
        add.b   $1234.w,d7
        add.b   $12345678,d0
        add.b   ($20,a0,a0),d0
        add.b   ($20,a0,a0.l),d0
        add.b   ($20,a0,a0.w),d0
        add.b   ($20,a0,d0),d0
        add.b   ($20,a0,d0.l),d0
        add.b   ($20,a0,d0.w),d0
        add.b   (a1),d1
        add.b   (a2)+,d2
        add.b   -(a3),d3
        add.b   d1,d0
        add.l   #$12345678,d4
        add.l   $12(a6,a7),d5
        add.l   $12(a6,d7),d6
        add.l   $12(pc,a1),d2
        add.l   $12(pc,d2),d3
        add.l   $1234(a5),d4
        add.l   $1234(pc),d1
        add.l   $1234.w,d7
        add.l   $12345678,d0
        add.l   (a1),d1
        add.l   (a2)+,d2
        add.l   -(a3),d3
        add.l   d0,$12345678
        add.l   d1,(a1)
        add.l   d1,d0
        add.l   d2,(a2)+
        add.l   d3,-(a3)
        add.l   d4,$1234(a5)
        add.l   d5,$12(a6,a7)
        add.l   d6,$12(a6,d7)
        add.l   d7,$1234.w
        add.w   #$1234,d4
        add.w   $12(a6,a7),d5
        add.w   $12(a6,d7),d6
        add.w   $1234(a5),d4
        add.w   $1234(pc),d1
        add.w   $1234.w,d7
        add.w   $12345678,d0
        add.w   (a1),d1
        add.w   (a2)+,d2
        add.w   -(a3),d3
        add.w   d1,d0
        adda.l  #$12345678,a1
        adda.l  $12(a6,a7),a1
        adda.l  $12(a6,d7),a2
        adda.l  $1234(a5),a6
        adda.l  $1234(pc),a5
        adda.l  $1234.w,a3
        adda.l  $12345678,a4
        adda.l  (a2),a3
        adda.l  (a3)+,a4
        adda.l  -(a4),a5
        adda.l  a1,a2
        adda.l  d1,a1
        adda.w  #$1234,a1
        adda.w  $12(a6,a7),a1
        adda.w  $12(a6,d7),a2
        adda.w  $1234(a5),a6
        adda.w  $1234(pc),a5
        adda.w  $1234.w,a3
        adda.w  $12345678,a4
        adda.w  (a2),a3
        adda.w  (a3)+,a4
        adda.w  -(a4),a5
        adda.w  a1,a2
        adda.w  d1,a1
        addi.b  #$12,$3456(a3)
        addi.b  #$12,(a0)
        addi.b  #$12,(a1)+
        addi.b  #$12,-(a2)
        addi.b  #$12,d0
        addi.b  #$34,$56(a3,a5)
        addi.b  #$34,$56(a3,d4)
        addi.b  #$56,$1234.w
        addi.b  #$78,$12345678
        addi.l  #$12345678,$3456(a3)
        addi.l  #$12345678,$4321.w
        addi.l  #$12345678,$76(a3,a5)
        addi.l  #$12345678,$76(a3,d4)
        addi.l  #$12345678,$87654321
        addi.l  #$12345678,(a0)
        addi.l  #$12345678,(a1)+
        addi.l  #$12345678,-(a2)
        addi.l  #$12345678,d0
        addi.w  #$1234,$3456(a3)
        addi.w  #$1234,$56(a3,a5)
        addi.w  #$1234,$56(a3,d4)
        addi.w  #$1234,$5678.w
        addi.w  #$1234,$87654321
        addi.w  #$1234,(a0)
        addi.w  #$1234,(a1)+
        addi.w  #$1234,-(a2)
        addi.w  #$1234,d0
        addq.b  #1,$12345678
        addq.b  #1,d0
        addq.b  #2,(a1)
        addq.b  #3,(a2)+
        addq.b  #4,-(a3)
        addq.b  #4,d0
        addq.b  #5,$1234(a5)
        addq.b  #6,$12(a6,a7)
        addq.b  #7,$12(a6,d7)
        addq.b  #7,d0
        addq.b  #8,$1234.w
        addq.l  #1,$12345678
        addq.l  #1,a1
        addq.l  #2,(a1)
        addq.l  #3,(a2)+
        addq.l  #3,d0
        addq.l  #4,-(a3)
        addq.l  #5,$1234(a5)
        addq.l  #6,$12(a6,a7)
        addq.l  #6,d0
        addq.l  #7,$12(a6,d7)
        addq.l  #8,$1234.w
        addq.l  #8,d0
        addq.w  #1,$12345678
        addq.w  #1,a1
        addq.w  #2,(a1)
        addq.w  #2,d0
        addq.w  #3,(a2)+
        addq.w  #4,-(a3)
        addq.w  #5,$1234(a5)
        addq.w  #5,d0
        addq.w  #6,$12(a6,a7)
        addq.w  #7,$12(a6,d7)
        addq.w  #8,$1234.w
        addq.w  #8,d0
        addx.b  -(a0),-(a1)
        addx.b  -(a6),-(a7)
        addx.b  d0,d1
        addx.b  d6,d7
        addx.l  -(a4),-(a5)
        addx.l  d4,d5
        addx.w  -(a2),-(a3)
        addx.w  d2,d3
        and.b   #$12,d4
        and.b   $12(a6,a7),d5
        and.b   $12(a6,d7),d6
        and.b   $1234(a5),d4
        and.b   $1234(pc),d1
        and.b   $1234.w,d7
        and.b   $12345678,d0
        and.b   (a1),d1
        and.b   (a2)+,d2
        and.b   -(a3),d3
        and.b   d1,d0
        and.l   #$12345678,d4
        and.l   $12(a6,a7),d5
        and.l   $12(a6,d7),d6
        and.l   $1234(a5),d4
        and.l   $1234(pc),d1
        and.l   $1234.w,d7
        and.l   $12345678,d0
        and.l   (a1),d1
        and.l   (a2)+,d2
        and.l   -(a3),d3
        and.l   d1,d0
        and.w   #$1234,d4
        and.w   $12(a6,a7),d5
        and.w   $12(a6,d7),d6
        and.w   $1234(a5),d4
        and.w   $1234(pc),d1
        and.w   $1234.w,d7
        and.w   $12345678,d0
        and.w   (a1),d1
        and.w   (a2)+,d2
        and.w   -(a3),d3
        and.w   d1,d0
        andi    #$55,ccr
        andi    #$aa55,sr
        andi.b  #$12,$3456(a3)
        andi.b  #$12,(a0)
        andi.b  #$12,(a1)+
        andi.b  #$12,-(a2)
        andi.b  #$12,d0
        andi.b  #$34,$56(a3,a5)
        andi.b  #$34,$56(a3,d4)
        andi.b  #$56,$1234.w
        andi.b  #$78,$12345678
        andi.l  #$12345678,$3456(a3)
        andi.l  #$12345678,$4321.w
        andi.l  #$12345678,$76(a3,a5)
        andi.l  #$12345678,$76(a3,d4)
        andi.l  #$12345678,$87654321
        andi.l  #$12345678,(a0)
        andi.l  #$12345678,(a1)+
        andi.l  #$12345678,-(a2)
        andi.l  #$12345678,d0
        andi.w  #$1234,$3456(a3)
        andi.w  #$1234,$56(a3,a5)
        andi.w  #$1234,$56(a3,d4)
        andi.w  #$1234,$5678.w
        andi.w  #$1234,$87654321
        andi.w  #$1234,(a0)
        andi.w  #$1234,(a1)+
        andi.w  #$1234,-(a2)
        andi.w  #$1234,d0
        asl     $12(a6,a7)
        asl     $12(a6,d7)
        asl     $1234(a5)
        asl     $1234.w
        asl     $12345678
        asl     (a2)
        asl     (a3)+
        asl     -(a4)
        asl.b   #1,d7
        asl.b   d0,d0
        asl.l   #7,d2
        asl.l   d0,d0
        asl.l   d5,d6
        asl.w   #3,d1
        asl.w   d0,d0
        asl.w   d3,d4
        asr     $12(a6,a7)
        asr     $12(a6,d7)
        asr     $1234(a5)
        asr     $1234.w
        asr     $12345678
        asr     (a2)
        asr     (a3)+
        asr     -(a4)
        asr.b   #2,d7
        asr.b   d1,d2
        asr.l   #8,d2
        asr.l   d5,d6
        asr.w   #4,d1
        asr.w   d3,d4
        bchg    #1,d2
        bchg    #2,(a2)
        bchg    #3,(a3)+
        bchg    #31,d3
        bchg    #4,-(a4)
        bchg    #5,$1234(a5)
        bchg    #6,$12(a6,a7)
        bchg    #7,$12(a6,d7)
        bchg    #8,$1234.w
        bchg    #9,$12345678
        bchg    d0,$12345678
        bchg    d0,d2
        bchg    d1,(a2)
        bchg    d2,(a3)+
        bchg    d3,-(a4)
        bchg    d4,$1234(a5)
        bchg    d5,$12(a6,a7)
        bchg    d6,$12(a6,d7)
        bchg    d7,$1234.w
        bclr    #1,d2
        bclr    #2,(a2)
        bclr    #3,(a3)+
        bclr    #31,d3
        bclr    #4,-(a4)
        bclr    #5,$1234(a5)
        bclr    #6,$12(a6,a7)
        bclr    #7,$12(a6,d7)
        bclr    #8,$1234.w
        bclr    #9,$12345678
        bclr    d0,$12345678
        bclr    d0,d2
        bclr    d1,(a2)
        bclr    d2,(a3)+
        bclr    d3,-(a4)
        bclr    d4,$1234(a5)
        bclr    d5,$12(a6,a7)
        bclr    d6,$12(a6,d7)
        bclr    d7,$1234.w
        bset    #1,d2
        bset    #2,(a2)
        bset    #3,(a3)+
        bset    #31,d3
        bset    #4,-(a4)
        bset    #5,$1234(a5)
        bset    #6,$12(a6,a7)
        bset    #7,$12(a6,d7)
        bset    #8,$1234.w
        bset    #9,$12345678
        bset    d0,$12345678
        bset    d0,d2
        bset    d1,(a2)
        bset    d2,(a3)+
        bset    d3,-(a4)
        bset    d4,$1234(a5)
        bset    d5,$12(a6,a7)
        bset    d6,$12(a6,d7)
        bset    d7,$1234.w
        btst    #1,d2
        btst    #10,$1234(pc)
        btst    #2,(a2)
        btst    #3,(a3)+
        btst    #31,d3
        btst    #4,-(a4)
        btst    #5,$1234(a5)
        btst    #6,$12(a6,a7)
        btst    #7,$12(a6,d7)
        btst    #8,$1234.w
        btst    #9,$12345678
        btst    d0,$12345678
        btst    d0,d2
        btst    d1,$1234(pc)
        btst    d1,(a2)
        btst    d2,(a3)+
        btst    d3,-(a4)
        btst    d4,$1234(a5)
        btst    d5,$12(a6,a7)
        btst    d6,$12(a6,d7)
        btst    d7,$1234.w
        chk     #$1234,d4
        chk     $12(a6,a7),d5
        chk     $12(a6,d7),d6
        chk     $1234(a5),d4
        chk     $1234(pc),d1
        chk     $1234.w,d7
        chk     $12345678,d0
        chk     (a1),d1
        chk     (a2)+,d2
        chk     -(a3),d3
        chk     d1,d0
        clr.b   $12(a6,a7)
        clr.b   $12(a6,d7)
        clr.b   $1234(a5)
        clr.b   $1234.w
        clr.b   $12345678
        clr.b   (a2)
        clr.b   (a3)+
        clr.b   -(a4)
        clr.b   d1
        clr.l   $12(a6,a7)
        clr.l   $12(a6,d7)
        clr.l   $1234(a5)
        clr.l   $1234.w
        clr.l   $12345678
        clr.l   (a2)
        clr.l   (a3)+
        clr.l   -(a4)
        clr.l   d1
        clr.w   $12(a6,a7)
        clr.w   $12(a6,d7)
        clr.w   $1234(a5)
        clr.w   $1234.w
        clr.w   $12345678
        clr.w   (a2)
        clr.w   (a3)+
        clr.w   -(a4)
        clr.w   d1
        cmp.b   #$12,d4
        cmp.b   $12(a6,a7),d5
        cmp.b   $12(a6,d7),d6
        cmp.b   $1234(a5),d4
        cmp.b   $1234(pc),d1
        cmp.b   $1234.w,d7
        cmp.b   $12345678,d0
        cmp.b   (a1),d1
        cmp.b   (a2)+,d2
        cmp.b   -(a3),d3
        cmp.b   d1,d0
        cmp.l   #$12345678,d4
        cmp.l   $12(a6,a7),d5
        cmp.l   $12(a6,d7),d6
        cmp.l   $1234(a5),d4
        cmp.l   $1234(pc),d1
        cmp.l   $1234.w,d7
        cmp.l   $12345678,d0
        cmp.l   (a1),d1
        cmp.l   (a2)+,d2
        cmp.l   -(a3),d3
        cmp.l   a1,d0
        cmp.l   d1,d0
        cmp.w   #$1234,d4
        cmp.w   $12(a6,a7),d5
        cmp.w   $12(a6,d7),d6
        cmp.w   $1234(a5),d4
        cmp.w   $1234(pc),d1
        cmp.w   $1234.w,d7
        cmp.w   $12345678,d0
        cmp.w   (a1),d1
        cmp.w   (a2)+,d2
        cmp.w   -(a3),d3
        cmp.w   a1,d0
        cmp.w   d1,d0
        cmpa.l  #$12345678,a1
        cmpa.l  $12(a6,a7),a1
        cmpa.l  $12(a6,d7),a2
        cmpa.l  $1234(a5),a6
        cmpa.l  $1234(pc),a5
        cmpa.l  $1234.w,a3
        cmpa.l  $12345678,a4
        cmpa.l  (a2),a3
        cmpa.l  (a3)+,a4
        cmpa.l  -(a4),a5
        cmpa.l  a1,a2
        cmpa.l  d1,a1
        cmpa.w  #$1234,a1
        cmpa.w  $12(a6,a7),a1
        cmpa.w  $12(a6,d7),a2
        cmpa.w  $1234(a5),a6
        cmpa.w  $1234(pc),a5
        cmpa.w  $1234.w,a3
        cmpa.w  $12345678,a4
        cmpa.w  (a2),a3
        cmpa.w  (a3)+,a4
        cmpa.w  -(a4),a5
        cmpa.w  a1,a2
        cmpa.w  d1,a1
        cmpi.b  #$12,$3456(a3)
        cmpi.b  #$12,(a0)
        cmpi.b  #$12,(a1)+
        cmpi.b  #$12,-(a2)
        cmpi.b  #$12,d0
        cmpi.b  #$34,$56(a3,a5)
        cmpi.b  #$34,$56(a3,d4)
        cmpi.b  #$56,$1234.w
        cmpi.b  #$78,$12345678
        cmpi.l  #$12345678,$3456(a3)
        cmpi.l  #$12345678,$4321.w
        cmpi.l  #$12345678,$76(a3,a5)
        cmpi.l  #$12345678,$76(a3,d4)
        cmpi.l  #$12345678,$87654321
        cmpi.l  #$12345678,(a0)
        cmpi.l  #$12345678,(a1)+
        cmpi.l  #$12345678,-(a2)
        cmpi.l  #$12345678,d0
        cmpi.w  #$1234,$3456(a3)
        cmpi.w  #$1234,$56(a3,a5)
        cmpi.w  #$1234,$56(a3,d4)
        cmpi.w  #$1234,$5678.w
        cmpi.w  #$1234,$87654321
        cmpi.w  #$1234,(a0)
        cmpi.w  #$1234,(a1)+
        cmpi.w  #$1234,-(a2)
        cmpi.w  #$1234,d0
        cmpm.b  (a0)+,(a1)+
        cmpm.b  (a3)+,(a4)+
        cmpm.l  (a2)+,(a3)+
        cmpm.l  (a5)+,(a6)+
        cmpm.l  (a7)+,(a7)+
        cmpm.w  (a1)+,(a2)+
        cmpm.w  (a4)+,(a5)+
        dc.w    $7777
        dc.w    $A234
        dc.w    $F123
        divs    #$1234,d4
        divs    $12(a6,a7),d5
        divs    $12(a6,d7),d6
        divs    $1234(a5),d4
        divs    $1234(pc),d1
        divs    $1234.w,d7
        divs    $12345678,d0
        divs    (a1),d1
        divs    (a2)+,d2
        divs    -(a3),d3
        divs    d1,d0
        divu    #$1234,d4
        divu    $12(a6,a7),d5
        divu    $12(a6,d7),d6
        divu    $1234(a5),d4
        divu    $1234(pc),d1
        divu    $1234.w,d7
        divu    $12345678,d0
        divu    (a1),d1
        divu    (a2)+,d2
        divu    -(a3),d3
        divu    d1,d0
        eor.b   #$12,d4
        eor.b   d1,d0
        eor.l   #$12345678,d4
        eor.l   d1,d0
        eor.w   #$1234,d4
        eor.w   d1,d0
        eori    #$aa,ccr
        eori    #$aa55,sr
        eori.b  #$12,$3456(a3)
        eori.b  #$12,(a0)
        eori.b  #$12,(a1)+
        eori.b  #$12,-(a2)
        eori.b  #$12,d0
        eori.b  #$34,$56(a3,a5)
        eori.b  #$34,$56(a3,d4)
        eori.b  #$56,$1234.w
        eori.b  #$78,$12345678
        eori.l  #$12345678,$3456(a3)
        eori.l  #$12345678,$4321.w
        eori.l  #$12345678,$76(a3,a5)
        eori.l  #$12345678,$76(a3,d4)
        eori.l  #$12345678,$87654321
        eori.l  #$12345678,(a0)
        eori.l  #$12345678,(a1)+
        eori.l  #$12345678,-(a2)
        eori.l  #$12345678,d0
        eori.w  #$1234,$3456(a3)
        eori.w  #$1234,$56(a3,a5)
        eori.w  #$1234,$56(a3,d4)
        eori.w  #$1234,$5678.w
        eori.w  #$1234,$87654321
        eori.w  #$1234,(a0)
        eori.w  #$1234,(a1)+
        eori.w  #$1234,-(a2)
        eori.w  #$1234,d0
        exg     a2,a3
        exg     a3,a4
        exg     a5,d6
        exg     d0,d0
        exg     d0,d1
        exg     d1,d2
        exg     d4,a5
        ext.l   d2
        ext.w   d6
        illegal
        jmp     $12(a3,d1)
        jmp     $1234(a2)
        jmp     $1234(pc)
        jmp     $1234.w
        jmp     $12345678
        jmp     $34(a4,a2)
        jmp     (a1)
        jsr     $12(a3,d1)
        jsr     $1234(a2)
        jsr     $1234(pc)
        jsr     $1234.w
        jsr     $12345678
        jsr     $34(a3,a2)
        jsr     (a1)
        lea     $12(a6,a7),a4
        lea     $12(a6,d7),a5
        lea     $1234(a2),a3
        lea     $1234(pc),a1
        lea     $1234.w,a6
        lea     $12345678,a7
        lea     (a1),a2
        link    a1,#$1234
        link    a7,#$AA55
        lsl     $12(a6,a7)
        lsl     $12(a6,d7)
        lsl     $1234(a5)
        lsl     $1234.w
        lsl     $12345678
        lsl     (a2)
        lsl     (a3)+
        lsl     -(a4)
        lsl.b   #1,d7
        lsl.b   d1,d2
        lsl.l   #7,d2
        lsl.l   d5,d6
        lsl.w   #3,d1
        lsl.w   d3,d4
        lsr     $12(a6,a7)
        lsr     $12(a6,d7)
        lsr     $1234(a5)
        lsr     $1234.w
        lsr     $12345678
        lsr     (a2)
        lsr     (a3)+
        lsr     -(a4)
        lsr.b   #2,d7
        lsr.b   d1,d2
        lsr.l   #8,d2
        lsr.l   d5,d6
        lsr.w   #4,d1
        lsr.w   d3,d4
        move    #$1234,ccr
        move    #$1234,sr
        move    $12(a6,a7),ccr
        move    $12(a6,a7),sr
        move    $12(a6,d7),ccr
        move    $12(a6,d7),sr
        move    $1234(a5),ccr
        move    $1234(a5),sr
        move    $1234(pc),ccr
        move    $1234(pc),sr
        move    $1234.w,ccr
        move    $1234.w,sr
        move    $12345678,ccr
        move    $12345678,sr
        move    (a2),ccr
        move    (a2),sr
        move    (a3)+,ccr
        move    (a3)+,sr
        move    -(a4),ccr
        move    -(a4),sr
        move    USP,a1
        move    a2,USP
        move    d1,ccr
        move    d1,sr
        move    sr,$12(a6,a7)
        move    sr,$12(a6,d7)
        move    sr,$1234(a5)
        move    sr,$1234.w
        move    sr,$12345678
        move    sr,(a2)
        move    sr,(a3)+
        move    sr,-(a4)
        move    sr,d1
        move.b  #$12,d7
        move.b  #$AA,($4321,a2)
        move.b  #1,($1234,a1)
        move.b  $12(a6,a7),d0
        move.b  $12(a6,d7),d1
        move.b  $1234(a5),d6
        move.b  $1234(pc),($18,a0,a0.w)
        move.b  $1234(pc),($18,a0,a1.l)
        move.b  $1234(pc),($18,a0,d0.w)
        move.b  $1234(pc),($18,a0,d2.l)
        move.b  $1234(pc),($2345,a0)
        move.b  $1234(pc),(a0)
        move.b  $1234(pc),(a0)+
        move.b  $1234(pc),-(a0)
        move.b  $1234(pc),d0
        move.b  $1234(pc),d4
        move.b  $1234.w,d2
        move.b  $12345678,$87654321
        move.b  $12345678,d3
        move.b  ($1234,a0),($56,a0,d7.w)
        move.b  ($1234,a1),($56,a0,d7.l)
        move.b  ($1234,a2),($56,a0,a0.w)
        move.b  ($1234,a3),($56,a0,a0.l)
        move.b  (a3),d3
        move.b  (a4)+,d4
        move.b  -(a5),d5
        move.b  d1,d1
        move.b  d1,d1
        move.b  d2,(a3)
        move.b  d3,(a4)+
        move.b  d4,-(a5)
        move.b  d5,$1234(a5)
        move.b  d6,$12(a6,a7)
        move.b  d7,$12(a6,d7)
        move.l  #$12345678,$87654321
        move.l  #$12345678,d7
        move.l  #$AA551122,($4321,a2)
        move.l  #3,($1234,a1)
        move.l  $12(a1,d0),$3456(a6)
        move.l  $12(a6,a7),d0
        move.l  $12(a6,d7),d1
        move.l  $1234(a5),d6
        move.l  $1234(pc),d4
        move.l  $1234.w,d2
        move.l  $12345678,$87654321
        move.l  $12345678,d3
        move.l  (a3),d3
        move.l  (a4)+,d4
        move.l  -(a5),d5
        move.l  a2,$12345678
        move.l  a2,d2
        move.l  d1,d1
        move.l  d2,(a3)
        move.l  d3,(a4)+
        move.l  d4,-(a5)
        move.l  d5,$1234(a5)
        move.l  d6,$12(a6,a7)
        move.l  d7,$12(a6,d7)
        move.w  #$1234,d7
        move.w  #$AA55,($4321,a2)
        move.w  #2,($1234,a1)
        move.w  $12(a4,d0),$3456(a5)
        move.w  $12(a6,a7),d0
        move.w  $12(a6,d7),d1
        move.w  $1234(a5),d6
        move.w  $1234(pc),d4
        move.w  $1234.w,d2
        move.w  $12345678,$87654321
        move.w  $12345678,d3
        move.w  (a3),d3
        move.w  (a4)+,d4
        move.w  -(a5),d5
        move.w  a2,$12345678
        move.w  a2,d2
        move.w  d1,d1
        move.w  d1,d1
        move.w  d2,(a3)
        move.w  d3,(a4)+
        move.w  d4,-(a5)
        move.w  d5,$1234(a5)
        move.w  d6,$12(a6,a7)
        move.w  d7,$12(a6,d7)
        movea.l #$12345678,a7
        movea.l $12(a6,a7),a7
        movea.l $12(a6,d7),a1
        movea.l $1234(a5),a6
        movea.l $1234(pc),a4
        movea.l $1234.w,a2
        movea.l $12345678,a3
        movea.l (a2),a3
        movea.l (a3)+,a4
        movea.l -(a4),a5
        movea.l a1,a2
        movea.l d0,a1
        movea.w #$1234,a7
        movea.w $12(a6,a7),a7
        movea.w $12(a6,d7),a1
        movea.w $1234(a5),a6
        movea.w $1234(pc),a4
        movea.w $1234.w,a2
        movea.w $12345678,a3
        movea.w (a2),a3
        movea.w (a3)+,a4
        movea.w -(a4),a5
        movea.w a1,a2
        movea.w d0,a1
        movem.l $12(a6,a7),d1/d3/d5/d7/a0/a2/a4/a6
        movem.l $12(a6,d7),d1/d3/d5/d7/a0/a2/a4/a6
        movem.l $1234(a5),d1/d3/d5/d7/a0/a2/a4/a6
        movem.l $1234(pc),d1/d3/d5/d7/a0/a2/a4/a6
        movem.l $1234.w,d1/d3/d5/d7/a0/a2/a4/a6
        movem.l $12345678,d1/d3/d5/d7/a0/a2/a4/a6
        movem.l (a1),d0-d7/a0-a7
        movem.l (a1),d1/d3/d5/d7/a0/a2/a4/a6
        movem.l (a2)+,d1/d3/d5/d7/a0/a2/a4/a6
        movem.l (a2),d1/a2
        movem.l (a4)+,d3/a4
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,$12(a6,a7)
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,$12(a6,d7)
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,$1234(a5)
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,$1234.w
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,$12345678
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,(a1)
        movem.l d1/d3/d5/d7/a0/a2/a4/a6,-(a3)
        movem.l d2/a3,-(a3)
        movem.w $12(a6,a7),d1/d3/d5/d7/a0/a2/a4/a6
        movem.w $12(a6,d7),d1/d3/d5/d7/a0/a2/a4/a6
        movem.w $1234(a5),d1/d3/d5/d7/a0/a2/a4/a6
        movem.w $1234(pc),d1/d3/d5/d7/a0/a2/a4/a6
        movem.w $1234.w,d1/d3/d5/d7/a0/a2/a4/a6
        movem.w $12345678,d1/d3/d5/d7/a0/a2/a4/a6
        movem.w (a1),d1/d3/d5/d7/a0/a2/a4/a6
        movem.w (a2)+,d1/d3/d5/d7/a0/a2/a4/a6
        movem.w a1/a3/a5/a7,$12(a6,a7)
        movem.w a1/a3/a5/a7,$1234.w
        movem.w a1/a3/a5/a7,-(a3)
        movem.w d1/d3/d5/d7,$12(a6,d7)
        movem.w d1/d3/d5/d7,$1234(a5)
        movem.w d1/d3/d5/d7,$12345678
        movem.w d1/d3/d5/d7,(a1)
        movep.l ($55aa,a5),d4
        movep.l d2,($2030,a3)
        movep.w ($3040,a4),d3
        movep.w d1,($1010,a2)
        moveq   #$55,d4
        moveq   #-1,d2
        moveq   #1,d1
        moveq   #127,d3
        muls    #$1234,d4
        muls    $12(a6,a7),d5
        muls    $12(a6,d7),d6
        muls    $1234(a5),d4
        muls    $1234(pc),d1
        muls    $1234.w,d7
        muls    $12345678,d0
        muls    (a1),d1
        muls    (a2)+,d2
        muls    -(a3),d3
        muls    d1,d0
        mulu    #$1234,d4
        mulu    $12(a6,a7),d5
        mulu    $12(a6,d7),d6
        mulu    $1234(a5),d4
        mulu    $1234(pc),d1
        mulu    $1234.w,d7
        mulu    $12345678,d0
        mulu    (a1),d1
        mulu    (a2)+,d2
        mulu    -(a3),d3
        mulu    d1,d0
        nbcd    $12(a6,a7)
        nbcd    $12(a6,d7)
        nbcd    $1234(a5)
        nbcd    $1234.w
        nbcd    $12345678
        nbcd    (a2)
        nbcd    (a3)+
        nbcd    -(a4)
        nbcd    d1
        neg.b   $12(a6,a7)
        neg.b   $12(a6,d7)
        neg.b   $1234(a5)
        neg.b   $1234.w
        neg.b   $12345678
        neg.b   (a2)
        neg.b   (a3)+
        neg.b   -(a4)
        neg.b   d1
        neg.l   $12(a6,a7)
        neg.l   $12(a6,d7)
        neg.l   $1234(a5)
        neg.l   $1234.w
        neg.l   $12345678
        neg.l   (a2)
        neg.l   (a3)+
        neg.l   -(a4)
        neg.l   d1
        neg.w   $12(a6,a7)
        neg.w   $12(a6,d7)
        neg.w   $1234(a5)
        neg.w   $1234.w
        neg.w   $12345678
        neg.w   (a2)
        neg.w   (a3)+
        neg.w   -(a4)
        neg.w   d1
        negx.b  $12(a6,a7)
        negx.b  $12(a6,d7)
        negx.b  $1234(a5)
        negx.b  $1234.w
        negx.b  $12345678
        negx.b  (a2)
        negx.b  (a3)+
        negx.b  -(a4)
        negx.b  d1
        negx.l  $12(a6,a7)
        negx.l  $12(a6,d7)
        negx.l  $1234(a5)
        negx.l  $1234.w
        negx.l  $12345678
        negx.l  (a2)
        negx.l  (a3)+
        negx.l  -(a4)
        negx.l  d1
        negx.w  $12(a6,a7)
        negx.w  $12(a6,d7)
        negx.w  $1234(a5)
        negx.w  $1234.w
        negx.w  $12345678
        negx.w  (a2)
        negx.w  (a3)+
        negx.w  -(a4)
        negx.w  d1
        nop
        not.b   $12(a6,a7)
        not.b   $12(a6,d7)
        not.b   $1234(a5)
        not.b   $1234.w
        not.b   $12345678
        not.b   (a2)
        not.b   (a3)+
        not.b   -(a4)
        not.b   d1
        not.l   $12(a6,a7)
        not.l   $12(a6,d7)
        not.l   $1234(a5)
        not.l   $1234.w
        not.l   $12345678
        not.l   (a2)
        not.l   (a3)+
        not.l   -(a4)
        not.l   d1
        not.w   $12(a6,a7)
        not.w   $12(a6,d7)
        not.w   $1234(a5)
        not.w   $1234.w
        not.w   $12345678
        not.w   (a2)
        not.w   (a3)+
        not.w   -(a4)
        not.w   d1
        or.b    #$12,d4
        or.b    $12(a6,a7),d5
        or.b    $12(a6,d7),d6
        or.b    $1234(a5),d4
        or.b    $1234(pc),d1
        or.b    $1234.w,d7
        or.b    $12345678,d0
        or.b    (a1),d1
        or.b    (a2)+,d2
        or.b    -(a3),d3
        or.b    d1,d0
        or.l    #$12345678,d4
        or.l    $12(a6,a7),d5
        or.l    $12(a6,d7),d6
        or.l    $1234(a5),d4
        or.l    $1234(pc),d1
        or.l    $1234.w,d7
        or.l    $12345678,d0
        or.l    (a1),d1
        or.l    (a2)+,d2
        or.l    -(a3),d3
        or.l    d1,d0
        or.w    #$1234,d4
        or.w    $12(a6,a7),d5
        or.w    $12(a6,d7),d6
        or.w    $1234(a5),d4
        or.w    $1234(pc),d1
        or.w    $1234.w,d7
        or.w    $12345678,d0
        or.w    (a1),d1
        or.w    (a2)+,d2
        or.w    -(a3),d3
        or.w    d0,$12345678
        or.w    d0,d1
        or.w    d1,(a1)
        or.w    d1,d0
        or.w    d2,(a2)+
        or.w    d3,-(a3)
        or.w    d4,$1234(a5)
        or.w    d5,$12(a6,a7)
        or.w    d6,$12(a6,d7)
        or.w    d7,$1234.w
        ori     #$aa,ccr
        ori     #$aa55,sr
        ori.b   #$12,$3456(a3)
        ori.b   #$12,(a0)
        ori.b   #$12,(a1)+
        ori.b   #$12,-(a2)
        ori.b   #$12,d0
        ori.b   #$34,$56(a3,a5)
        ori.b   #$34,$56(a3,d4)
        ori.b   #$56,$1234.w
        ori.b   #$78,$12345678
        ori.l   #$12345678,$3456(a3)
        ori.l   #$12345678,$4321.w
        ori.l   #$12345678,$76(a3,a5)
        ori.l   #$12345678,$76(a3,d4)
        ori.l   #$12345678,$87654321
        ori.l   #$12345678,(a0)
        ori.l   #$12345678,(a1)+
        ori.l   #$12345678,-(a2)
        ori.l   #$12345678,d0
        ori.w   #$1234,$3456(a3)
        ori.w   #$1234,$56(a3,a5)
        ori.w   #$1234,$56(a3,d4)
        ori.w   #$1234,$5678.w
        ori.w   #$1234,$87654321
        ori.w   #$1234,(a0)
        ori.w   #$1234,(a1)+
        ori.w   #$1234,-(a2)
        ori.w   #$1234,d0
        pea     $12(a6,a7)
        pea     $12(a6,d7)
        pea     $1234(a5)
        pea     $1234(pc)
        pea     $1234.w
        pea     $12345678
        pea     (a2)
        reset
        rol     $12(a6,a7)
        rol     $12(a6,d7)
        rol     $1234(a5)
        rol     $1234.w
        rol     $12345678
        rol     (a2)
        rol     (a3)+
        rol     -(a4)
        rol.b   #1,d7
        rol.b   d1,d2
        rol.l   #7,d2
        rol.l   d5,d6
        rol.w   #3,d1
        rol.w   d3,d4
        ror     $12(a6,a7)
        ror     $12(a6,d7)
        ror     $1234(a5)
        ror     $1234.w
        ror     $12345678
        ror     (a2)
        ror     (a3)+
        ror     -(a4)
        ror.b   #2,d7
        ror.b   d1,d2
        ror.l   #8,d2
        ror.l   d5,d6
        ror.w   #4,d1
        ror.w   d3,d4
        roxl    $12(a6,a7)
        roxl    $12(a6,d7)
        roxl    $1234(a5)
        roxl    $1234.w
        roxl    $12345678
        roxl    (a2)
        roxl    (a3)+
        roxl    -(a4)
        roxl.b  #1,d7
        roxl.b  d1,d2
        roxl.l  #7,d2
        roxl.l  d5,d6
        roxl.w  #3,d1
        roxl.w  d3,d4
        roxr    $12(a6,a7)
        roxr    $12(a6,d7)
        roxr    $1234(a5)
        roxr    $1234.w
        roxr    $12345678
        roxr    (a2)
        roxr    (a3)+
        roxr    -(a4)
        roxr.b  #2,d7
        roxr.b  d1,d2
        roxr.l  #8,d2
        roxr.l  d5,d6
        roxr.w  #4,d1
        roxr.w  d3,d4
        rte
        rtr
        rts
        sbcd    -(a3),-(a4)
        sbcd    -(a6),-(a7)
        sbcd    d1,d2
        sbcd    d3,d4
        scc     $1234(a5)
        scs     $12(a6,a7)
        seq     $1234.w
        sf      (a1)
        sge     -(a4)
        sgt     $12(a6,a7)
        shi     (a2)+
        sle     $1234.w
        sle     $12345678
        sls     -(a3)
        slt     $1234(a5)
        smi     (a3)+
        sne     $12(a6,d7)
        spl     (a2)
        st      d1
        stop    #$1234
        sub.b   #$12,d4
        sub.b   $12(a6,a7),d5
        sub.b   $12(a6,d7),d6
        sub.b   $1234(a5),d4
        sub.b   $1234(pc),d1
        sub.b   $1234.w,d7
        sub.b   $12345678,d0
        sub.b   (a1),d1
        sub.b   (a2)+,d2
        sub.b   -(a3),d3
        sub.b   d1,d0
        sub.l   #$12345678,d4
        sub.l   $12(a6,a7),d5
        sub.l   $12(a6,d7),d6
        sub.l   $1234(a5),d4
        sub.l   $1234(pc),d1
        sub.l   $1234.w,d7
        sub.l   $12345678,d0
        sub.l   (a1),d1
        sub.l   (a2)+,d2
        sub.l   -(a3),d3
        sub.l   d1,d0
        sub.w   #$1234,d4
        sub.w   $12(a6,a7),d5
        sub.w   $12(a6,d7),d6
        sub.w   $1234(a5),d4
        sub.w   $1234(pc),d1
        sub.w   $1234.w,d7
        sub.w   $12345678,d0
        sub.w   (a1),d1
        sub.w   (a2)+,d2
        sub.w   -(a3),d3
        sub.w   d1,d0
        suba.l  #$12345678,a1
        suba.l  $12(a6,a7),a1
        suba.l  $12(a6,d7),a2
        suba.l  $1234(a5),a6
        suba.l  $1234(pc),a5
        suba.l  $1234.w,a3
        suba.l  $12345678,a4
        suba.l  (a2),a3
        suba.l  (a3)+,a4
        suba.l  -(a4),a5
        suba.l  a1,a2
        suba.l  d1,a1
        suba.w  #$1234,a1
        suba.w  $12(a6,a7),a1
        suba.w  $12(a6,d7),a2
        suba.w  $1234(a5),a6
        suba.w  $1234(pc),a5
        suba.w  $1234.w,a3
        suba.w  $12345678,a4
        suba.w  (a2),a3
        suba.w  (a3)+,a4
        suba.w  -(a4),a5
        suba.w  a1,a2
        suba.w  d1,a1
        subi.b  #$12,$3456(a3)
        subi.b  #$12,(a0)
        subi.b  #$12,(a1)+
        subi.b  #$12,-(a2)
        subi.b  #$12,d0
        subi.b  #$34,$56(a3,a5)
        subi.b  #$34,$56(a3,d4)
        subi.b  #$56,$1234.w
        subi.b  #$78,$12345678
        subi.l  #$12345678,$3456(a3)
        subi.l  #$12345678,$4321.w
        subi.l  #$12345678,$76(a3,a5)
        subi.l  #$12345678,$76(a3,d4)
        subi.l  #$12345678,$87654321
        subi.l  #$12345678,(a0)
        subi.l  #$12345678,(a1)+
        subi.l  #$12345678,-(a2)
        subi.l  #$12345678,d0
        subi.w  #$1234,$3456(a3)
        subi.w  #$1234,$56(a3,a5)
        subi.w  #$1234,$56(a3,d4)
        subi.w  #$1234,$5678.w
        subi.w  #$1234,$87654321
        subi.w  #$1234,(a0)
        subi.w  #$1234,(a1)+
        subi.w  #$1234,-(a2)
        subi.w  #$1234,d0
        subq.b  #1,$12345678
        subq.b  #1,d0
        subq.b  #2,(a1)
        subq.b  #3,(a2)+
        subq.b  #4,-(a3)
        subq.b  #4,d0
        subq.b  #5,$1234(a5)
        subq.b  #6,$12(a6,a7)
        subq.b  #7,$12(a6,d7)
        subq.b  #7,d0
        subq.b  #8,$1234.w
        subq.l  #1,$12345678
        subq.l  #1,a1
        subq.l  #2,(a1)
        subq.l  #3,(a2)+
        subq.l  #3,d0
        subq.l  #4,-(a3)
        subq.l  #5,$1234(a5)
        subq.l  #6,$12(a6,a7)
        subq.l  #6,d0
        subq.l  #7,$12(a6,d7)
        subq.l  #8,$1234.w
        subq.l  #8,d0
        subq.w  #1,$12345678
        subq.w  #1,a1
        subq.w  #2,(a1)
        subq.w  #2,d0
        subq.w  #3,(a2)+
        subq.w  #4,-(a3)
        subq.w  #5,$1234(a5)
        subq.w  #5,d0
        subq.w  #6,$12(a6,a7)
        subq.w  #7,$12(a6,d7)
        subq.w  #8,$1234.w
        subq.w  #8,d0
        subx.b  -(a0),-(a1)
        subx.b  -(a6),-(a7)
        subx.b  d0,d1
        subx.b  d6,d7
        subx.l  -(a4),-(a5)
        subx.l  d4,d5
        subx.w  -(a2),-(a3)
        subx.w  d2,d3
        svc     $12345678
        svs     d2
        swap    d1
        swap    d7
        tas     $12(a6,a7)
        tas     $12(a6,d7)
        tas     $1234(a5)
        tas     $1234.w
        tas     $12345678
        tas     (a2)
        tas     (a3)+
        tas     -(a4)
        tas     d1
        trap    #0
        trap    #15
        trapv
        tst.b   $12(a6,a7)
        tst.b   $12(a6,d7)
        tst.b   $1234(a5)
        tst.b   $1234.w
        tst.b   $12345678
        tst.b   (a2)
        tst.b   (a3)+
        tst.b   -(a4)
        tst.b   d1
        tst.l   $12(a6,a7)
        tst.l   $12(a6,d7)
        tst.l   $1234(a5)
        tst.l   $1234.w
        tst.l   $12345678
        tst.l   (a2)
        tst.l   (a3)+
        tst.l   -(a4)
        tst.l   d1
        tst.w   $12(a6,a7)
        tst.w   $12(a6,d7)
        tst.w   $1234(a5)
        tst.w   $1234.w
        tst.w   $12345678
        tst.w   (a2)
        tst.w   (a3)+
        tst.w   -(a4)
        tst.w   d1
        unlk    a1
        unlk    a6
